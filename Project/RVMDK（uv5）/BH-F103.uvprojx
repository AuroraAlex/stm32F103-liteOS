# Keil uVision project BH-F103.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\HUAWEI_LiteOS\arch\arm\arm-m\include;..\..\HUAWEI_LiteOS\kernel\base\include;..\..\HUAWEI_LiteOS\kernel\extended\include;..\..\HUAWEI_LiteOS\kernel\include;..\..\HUAWEI_LiteOS\OS_CONFIG;..\..\User\flash;..\..\User\font;..\..\User\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/font/: fonts.c
    ../../User/lcd/: bsp_ili9341_lcd.c
  group HUAWEI_LITEOS_KERNEL
    ../../HUAWEI_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../HUAWEI_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../HUAWEI_LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../HUAWEI_LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../HUAWEI_LiteOS/kernel/base/mem/membox/: los_membox.c
    ../../HUAWEI_LiteOS/kernel/base/misc/: los_misc.c
    ../../HUAWEI_LiteOS/kernel/base/om/: los_err.c
    ../../HUAWEI_LiteOS/kernel/: los_init.c
    ../../HUAWEI_LiteOS/kernel/extended/tickless/: los_tickless.c
  group HUAWEI_LITEOS_ARCH
    ../../HUAWEI_LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../HUAWEI_LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
